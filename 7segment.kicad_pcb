# Repository adrienkohlbecker/7segment

File README.md:

# 7 segment hex display

## Board

## Schematic

## KiCad design 7segment.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 100n; C_0402_1005Metric
C6: 10u; C_0603_1608Metric
D1: 1N4148; D_SOD-323F
J1: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J2: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Left
JP1: MODE; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 10u; L_0603_1608Metric
Q1, Q2: Q_NPN_BEC; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R9, R10, R11, R12, R13: 4.7k; R_0402_1005Metric
R14: 10k; R_0402_1005Metric
U1: ATmega168PA-AU; TQFP-32_7x7mm_P0.8mm
U2: HDSP-523; DA56-11SURKWA

Connections:
/AVCC: C2.1, L1.1, U1.18 (AVCC)
/D0: J2.2, U1.12 (PB0)
/D1: J2.3, U1.13 (PB1)
/D2: J2.4, U1.14 (PB2)
/D3: J2.5, R9.1
/D4: J2.6, R10.1
/D5: J2.7, R11.1
/D6: J2.8, U1.7 (XTAL1/PB6)
/D7: J2.9, U1.8 (XTAL2/PB7)
/DIG_1: Q1.3 (C), U2.14 (DIG1_CC)
/DIG_2: Q2.3 (C), U2.13 (DIG2_CC)
/DIG_A: R1.1, U2.11 (DIG2_A), U2.16 (DIG1_A)
/DIG_B: R2.1, U2.10 (DIG2_B), U2.15 (DIG1_B)
/DIG_C: R3.1, U2.3 (DIG1_C), U2.8 (DIG2_C)
/DIG_D: R4.1, U2.2 (DIG1_D), U2.6 (DIG2_D)
/DIG_E: R5.1, U2.1 (DIG1_E), U2.5 (DIG2_E)
/DIG_F: R6.1, U2.12 (DIG2_F), U2.18 (DIG1_F)
/DIG_G: R7.1, U2.7 (DIG2_G), U2.17 (DIG1_G)
/DIG_P: R8.1, U2.4 (DP1), U2.9 (DP2)
/LEFT_DIGIT: R12.2, U1.26 (PC3)
/MISO: J1.1 (MISO), R10.2, U1.16 (PB4)
/MODE: JP1.1 (A), U1.25 (PC2)
/MOSI: J1.4 (MOSI), R9.2, U1.15 (PB3)
/RIGHT_DIGIT: R13.2, U1.27 (PC4)
/SCK: J1.3 (SCK), R11.2, U1.17 (PB5)
/ZERO_I_OR_OE: J2.10, U1.23 (PC0)
/ZERO_O: J2.1, U1.24 (PC1)
/~RST: C5.1, D1.2 (A), J1.5 (~RST), R14.1, U1.29 (~RESET/PC6)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.6 (GND), J4.2, JP1.2 (B), Q1.2 (E), Q2.2 (E), U1.3 (GND), U1.5 (GND), U1.21 (GND)
unnamed: C4.1, U1.20 (AREF)
unnamed: Q1.1 (B), R12.1
unnamed: Q2.1 (B), R13.1
unnamed: R1.2, U1.30 (PD0)
unnamed: R2.2, U1.31 (PD1)
unnamed: R3.2, U1.32 (PD2)
unnamed: R4.2, U1.1 (PD3)
unnamed: R5.2, U1.2 (PD4)
unnamed: R6.2, U1.9 (PD5)
unnamed: R7.2, U1.10 (PD6)
unnamed: R8.2, U1.11 (PD7)
VCC: C1.1, C3.1, C6.1, D1.1 (K), J1.2 (VCC), J4.1, L1.2, R14.2, U1.4 (VCC), U1.6 (VCC)

Notes on the sheet:
If mode is open: Works with zero blanking chaining. if Pin 1 is high, display both zeros, and drive pin 10 high if Pin 1 is low, zeroes become blank, and if the value is zero on both displays, drive pin 10 low If mode is closed: Pin 1 becomes Output Enable. when low: only the right dot is turned on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
At 50% duty cycle: Red HDSP-523E 270 ohms Green HDSP-523G 120 ohms Yellow HDSP-523Y 100 ohms

Board: 4 copper layers, 22.5 x 25.1 mm, 30 parts (21 on the bottom side), 41 nets.

## Commit log

2021-12-19 Add 7 segment display
2021-12-19 Update 7segment
2021-12-19 Add arduino code
2021-12-19 Add assembly
2021-12-26 Update 7 segment
2021-12-28 Update to KiCad 6
2021-12-29 FIx assembly
2022-01-03 Update footprints from library
2023-06-07 Fix digits
2023-06-30 Replace latch with output enable
